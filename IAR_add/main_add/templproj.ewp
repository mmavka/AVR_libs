# IAR project templproj.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=$EXE_DIR$\fl_$PROJ_FNAME$.hex; -Ointel-standard,(XDATA)=$EXE_DIR$\ee_$PROJ_FNAME$.eep; -Oubrof7=$EXE_DIR$\u7_$PROJ_FNAME$.d90; -Oubrof8=$EXE_DIR$\u8_$PROJ_FNAME$.d90; -we183
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  group (top)
    ./: main.c
  group compilers
    compilers/: compilers.h
  group serial
    serial/: serial.c serial.h
